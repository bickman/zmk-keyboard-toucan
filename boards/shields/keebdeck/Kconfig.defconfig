## boards/shields/keebdeck/Kconfig.defconfig
```kconfig
if SHIELD_KEEBDECK

config ZMK_KEYBOARD_NAME
    default "keebdeck"

endif

config RGBLED_WIDGET_BATTERY_LEVEL_HIGH
    default 40
```
